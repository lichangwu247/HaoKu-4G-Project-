# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: usrbin0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\DMA;..\SYSTEM\dbg;..\HARDWARE\MOBILE;..\MIDDLEWARE\MQTT;..\MIDDLEWARE\MQTTClient;..\SYSTEM\ringbuf;..\HARDWARE\RTC;..\MIDDLEWARE\IOT;..\HARDWARE\CHIP;..\STM32_Cryptographic\Inc;..\STM32_Cryptographic;..\HARDWARE\I2C;..\HARDWARE\PVD;..\MIDDLEWARE\DEVICE;..\SYSTEM\list;..\SYSTEM\protobuf;..\SYSTEM\encoding;..\MIDDLEWARE\ROUTINE;..\HARDWARE\FLASH;..\HARDWARE\SELECTOR;..\HARDWARE\UPGRADE
  memory RVCT4: ROM 0x8003000 size 0x1e000
  memory RVCT5: ROM 0x8021000 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c usr_task.c
    ../MIDDLEWARE/IOT/: iot.c
    ../MIDDLEWARE/DEVICE/: device.c prize.c
    ../MIDDLEWARE/ROUTINE/: routine.c
  group MQTTClient
    ../MIDDLEWARE/MQTTClient/: MQTTClient.c MQTTFreeRTOS.c mqtt_client.c
  group MQTT
    ../MIDDLEWARE/MQTT/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/MOBILE/: mobile.c mobile_net.c mobile_startup.c gprs.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/CHIP/: chip.c
    ../HARDWARE/I2C/: 24cxx.c myiic.c info_storage.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/PVD/: pvd.c
    ../HARDWARE/SELECTOR/: selector.c
    ../HARDWARE/UPGRADE/: hexbin.c upgrade.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart1.c usart2.c usart3.c
    ../SYSTEM/dbg/: dbg.c
    ../SYSTEM/ringbuf/: ringbuf.c
    ../SYSTEM/list/: sys_list.c
    ../SYSTEM/encoding/: encoding.c
    ../SYSTEM/protobuf/: protobuf.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_flash.c stm32f10x_exti.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group STM32_Crypto
    ../STM32_Cryptographic/: hash_crypt.c
    ../STM32_Cryptographic/Lib/: M3_CryptoFW_2_0_6.lib
  group README
    ../: readme.txt
